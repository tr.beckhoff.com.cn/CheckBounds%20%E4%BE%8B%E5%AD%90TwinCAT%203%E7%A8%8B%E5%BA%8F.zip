VAR_GLOBAL
	giCheckUnder			: DINT; // CheckBounds lower Bound
	giCheckOver				: DINT; // CheckBounds upper Bound
END_VAR
