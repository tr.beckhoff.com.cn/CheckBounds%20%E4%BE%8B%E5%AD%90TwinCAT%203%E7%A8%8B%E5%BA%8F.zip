PROGRAM MAIN
//SwenChen 数组越界测试程序
VAR
	aArray:			ARRAY[1..5] OF INT;
	bTest: 			BOOL;
	a: 				INT;
END_VAR


a:=9;
IF bTest THEN
	aArray[a]:= 1;	
	bTest:= FALSE;
END_IF

END_PROGRAM
